FILESEXTRAPATHS:append := "${THISDIR}/files:"
SRC_URI += " file://usb-autosuspend.rules"
