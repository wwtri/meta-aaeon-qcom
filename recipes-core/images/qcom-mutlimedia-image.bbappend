
IMAGE_INSTALL:append = " libdrm-tests"