
OS_RELEASE_FIELDS += " IMAGE_VERSION IMAGE_DATE"

IMAGE_VERSION = "v01"
IMAGE_DATE = "2026/03/25"
