FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " file://init_qti"
SRC_URI += " file://init_qti.service"